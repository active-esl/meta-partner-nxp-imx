SRCBRANCH:imx95-frdm-evk = "lf-6.12.49_2.2.0"
SRCREV:imx95-frdm-evk = "be80fadd5e7988214149a2bc48daac1b0950d4c2"
